options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_low_pass
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 10e3
    gain: '1'
    samp_rate: interp_samp_rate
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: freq0
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: id_ratio
  id: variable
  parameters:
    value: '20'
  states: {}
- name: interp_samp_rate
  id: variable
  parameters:
    value: 48000 * id_ratio
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1102500'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '10'
    type: float
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: 300.031431e3
    offset: '-1'
    phase: '0'
    samp_rate: interp_samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: 100e3
    offset: '-1'
    phase: '0'
    samp_rate: interp_samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 309e3
    low_cutoff_freq: 300.3e3
    samp_rate: interp_samp_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2500'
    low_cutoff_freq: '100'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 309e3
    low_cutoff_freq: 300.9e3
    samp_rate: interp_samp_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_1_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '9000'
    low_cutoff_freq: '300'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: interp_samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: audio_samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/karolf/projects/cessb/wav/Pobrane - sq5kvs_test2.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: audio_samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    name: '"audio"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: interp_samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    name: '"RF"'
    type: float
    ymin: '-180'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '4096'
    srate: interp_samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.4'
    interp: id_ratio
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: id_ratio
    fbw: '0.4'
    interp: '1'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_xx_0_0, '2']
- [analog_rail_ff_0, '0', band_pass_filter_0_0_1, '0']
- [analog_rail_ff_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [analog_rail_ff_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0_0, '0', analog_rail_ff_0, '0']
- [band_pass_filter_0_0_0, '0', rational_resampler_xxx_0, '0']
- [band_pass_filter_0_0_1, '0', blocks_multiply_xx_0_0, '0']
- [band_pass_filter_0_0_1_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', band_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_throttle2_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle2_0_0_0, '0', band_pass_filter_0_0_1_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle2_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_throttle2_0_0_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0

options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_low_pass
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 10e3
    gain: '1'
    samp_rate: interp_samp_rate
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '22050'
  states: {}
- name: freq0
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: interp_samp_rate
  id: variable
  parameters:
    value: 22050*50
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1102500'
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '0.005'
    lo: '-0.005'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 100e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 100e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '22050'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 104e3
    low_cutoff_freq: 100.5e3
    samp_rate: interp_samp_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '200'
    high_cutoff_freq: 104e3
    low_cutoff_freq: 100.5e3
    samp_rate: interp_samp_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: interp_samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: audio_samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/karolf/sq5kvs_test_kompresji
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: audio_samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    name: '"audio"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: audio_samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.3'
    interp: '50'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    fbw: '0.3'
    interp: '1'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_rail_ff_0, '0', band_pass_filter_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_multiply_xx_0, '0', analog_rail_ff_0, '0']
- [blocks_multiply_xx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_throttle2_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle2_0_0_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle2_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_throttle2_0_0_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
